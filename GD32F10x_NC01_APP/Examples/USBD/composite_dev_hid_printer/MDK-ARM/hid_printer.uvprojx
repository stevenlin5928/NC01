# Keil uVision project hid_printer.uvprojx, settings and files
target hid_printer_composite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hid_printer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F10X_HD
  c misc: --c99
  c include: ..\inc;..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\usbd\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\device\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\class\device\hid\Include;..\..\..\..\Firmware\GD32F10x_usbd_library\class\device\printer\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../src/: main.c gd32f10x_it.c hid_printer_wrapper.c gd32f10x_usbd_hw.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f10x_eval.c
  group USBD_Drivers
    ../../../../Firmware/GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../Firmware/GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../Firmware/GD32F10x_usbd_library/class/device/hid/Source/: custom_hid_core.c
    ../../../../Firmware/GD32F10x_usbd_library/class/device/printer/Source/: printer_core.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
