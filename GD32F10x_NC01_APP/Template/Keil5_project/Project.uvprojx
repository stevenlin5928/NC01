# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F107VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_common;..\..\Firmware\GD32F10x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f10x_it.c systick.c main.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group Utilities
    ../../Utilities/: utility.c
  group Doc
    ../: readme.txt
  group W5500
    ../../W5500/: attcp.c auto_update.c config.c socket.c udp_config.c w5500.c w5500_conf.c fw_update.c secstcp.c
  group Queue
    ../../queue/: queue.c
  group SIO
    ../../sio/: sio.c
  group SPI
    ../../SPI/: bsp_spi_eth.c
  group Board
    ../../Board/: Board.c
  group SECS
    ../../SECS/: secs.c
  group Beep
    ../../Beep/: Beep.c
  group Watchdog
    ../../Wdt_hw/: wdt_hw.c
  group LED
    ../../LED/: Led.c
  group RTC
    ../../Rtc/: rtc.c
  group CRC
    ../../crc/: Crc16_xmodem.c
  group RS485
    ../../rs485/: rs485.c
  group GPIO
    ../../gpio/: gp_io.c
  group display_max7219
    ../../max7219/: max7219.c
  group Keypad
    ../../Keypad/: keypad.c
  group SHT_IO
    ../../SHT_IO/: I2C_IO.c SHT2x.c
target GD32F10X_MD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nc01-App +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output *.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_common;..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\queue;..\..\ringbuffer;..\..\W5500;..\..\sio;..\..\SPI;..\..\Board;..\..\Barcode;..\..\LF;..\..\u8g2\csrc;..\..\u8g2\sys\arm\gd32;..\..\SECS;..\..\Beep;..\..\Wdt_hw;..\..\Led;..\..\Rtc;..\..\Crc;..\..\rs485;..\..\gpio;..\..\sht;..\..\max7219;..\..\Keypad;..\..\SHT_IO
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target GD32F10X_XD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VK GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
